# Keil uVision project Whatever You Want_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Whatever You Want_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Pin_1_aliases.h Pin_1.c Pin_1.h inter_1.c inter_1.h PWM.c PWM.h PWM_PM.c Clock_1.c Clock_1.h Pin_2_aliases.h Pin_2.c Pin_2.h Counter.c Counter.h Counter_PM.c inter_2.c inter_2.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Whatever You Want_PSoC5lib (library)
