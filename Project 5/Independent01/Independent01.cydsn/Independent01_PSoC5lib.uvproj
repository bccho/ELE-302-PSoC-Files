# Keil uVision project Independent01_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Independent01_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h PWM_Front_Left.c PWM_Front_Left.h PWM_Front_Left_PM.c Clock_1.c Clock_1.h Front_Left_Reverse_aliases.h Front_Left_Reverse.c Front_Left_Reverse.h Front_Left_Forward_aliases.h Front_Left_Forward.c Front_Left_Forward.h PWM_Front_Right.c PWM_Front_Right.h PWM_Front_Right_PM.c Front_Right_Reverse_aliases.h Front_Right_Reverse.c Front_Right_Reverse.h Front_Right_Forward_aliases.h Front_Right_Forward.c Front_Right_Forward.h PWM_Back_Left.c PWM_Back_Left.h PWM_Back_Left_PM.c Back_Left_Reverse_aliases.h Back_Left_Reverse.c Back_Left_Reverse.h Back_Left_Forward_aliases.h Back_Left_Forward.c Back_Left_Forward.h PWM_Back_Right.c PWM_Back_Right.h PWM_Back_Right_PM.c Back_Right_Reverse_aliases.h Back_Right_Reverse.c Back_Right_Reverse.h Back_Right_Forward_aliases.h Back_Right_Forward.c Back_Right_Forward.h UART.c UART.h UART_PM.c UART_INT.c cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h rx_rcvd.c rx_rcvd.h Control_Reg_Direction.c Control_Reg_Direction.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Independent01_PSoC5lib (library)
