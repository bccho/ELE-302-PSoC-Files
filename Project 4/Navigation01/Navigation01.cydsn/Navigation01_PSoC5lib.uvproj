# Keil uVision project Navigation01_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Navigation01_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h LCD.c LCD.h LCD_PM.c Pin_button_aliases.h Pin_button.c Pin_button.h inter_button.c inter_button.h Pin_motor_aliases.h Pin_motor.c Pin_motor.h Clock_1.c Clock_1.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h rx_rcvd.c rx_rcvd.h Hall_sensor_aliases.h Hall_sensor.c Hall_sensor.h wheel_tick.c wheel_tick.h tick_timeout.c tick_timeout.h throttle_update.c throttle_update.h Clock_2.c Clock_2.h PWM_Motor.c PWM_Motor.h PWM_Motor_PM.c UART.c UART.h UART_PM.c UART_INT.c Counter_PID.c Counter_PID.h Counter_PID_PM.c Timer_Wheel_Tick.c Timer_Wheel_Tick.h Timer_Wheel_Tick_PM.c Counter_Tick_Timeout.c Counter_Tick_Timeout.h Counter_Tick_Timeout_PM.c PWM_Servo.c PWM_Servo.h PWM_Servo_PM.c Pin_servo_aliases.h Pin_servo.c Pin_servo.h Clock_3.c Clock_3.h Vertical_sync_aliases.h Vertical_sync.c Vertical_sync.h Horiz_sync_aliases.h Horiz_sync.c Horiz_sync.h Comparator_aliases.h Comparator.c Comparator.h Camera_data_aliases.h Camera_data.c Camera_data.h camera_frame_start.c camera_frame_start.h Timer_Line_Begin.c Timer_Line_Begin.h Timer_Line_Begin_PM.c camera_comp_rise.c camera_comp_rise.h Timer_Line_End.c Timer_Line_End.h Timer_Line_End_PM.c camera_comp_fall.c camera_comp_fall.h Counter_Last_Row.c Counter_Last_Row.h Counter_Last_Row_PM.c Counter_First_Row.c Counter_First_Row.h Counter_First_Row_PM.c Trigger_aliases.h Trigger.c Trigger.h Line_begin_aliases.h Line_begin.c Line_begin.h Line_end_aliases.h Line_end.c Line_end.h Comp_out_aliases.h Comp_out.c Comp_out.h Horiz_out_aliases.h Horiz_out.c Horiz_out.h Vert_out_aliases.h Vert_out.c Vert_out.h Counter_Comp_Ignore.c Counter_Comp_Ignore.h Counter_Comp_Ignore_PM.c CompIgnore_out_aliases.h CompIgnore_out.c CompIgnore_out.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Navigation01_PSoC5lib (library)
