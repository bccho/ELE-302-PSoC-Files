# Keil uVision project SpeedControl01_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: SpeedControl01_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h LCD.c LCD.h LCD_PM.c Pin_button_aliases.h Pin_button.c Pin_button.h inter_button.c inter_button.h PWM.c PWM.h PWM_PM.c Pin_motor_aliases.h Pin_motor.c Pin_motor.h Clock_1.c Clock_1.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c rx_rcvd.c rx_rcvd.h Hall_sensor_aliases.h Hall_sensor.c Hall_sensor.h wheel_tick.c wheel_tick.h Timer_1.c Timer_1.h Timer_1_PM.c Counter_1.c Counter_1.h Counter_1_PM.c tick_timeout.c tick_timeout.h ShiftReg_1.c ShiftReg_1.h ShiftReg_1_PM.c Counter_2.c Counter_2.h Counter_2_PM.c throttle_update.c throttle_update.h Clock_2.c Clock_2.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: SpeedControl01_PSoC5lib (library)
